# hmmm inherit gobject-introspection
# suggested at https://patchwork.openembedded.org/patch/118069/ but gives problems
# trying more fine grained path
# required for python binding
export HOST_SYS
export BUILD_SYS
export STAGING_LIBDIR
export STAGING_INCDIR
